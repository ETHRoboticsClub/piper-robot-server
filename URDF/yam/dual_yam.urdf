Commit message: Not connect to arm yet

File: URDF/yam/dual_yam.urdf (robot description, URDF)
Before this commit: robot yam_v0, 14 links, 13 joints
Joints:
- joint base_to_arm2_base_joint: origin xyz=0 0.5 0 rpy=0 0 0 -> xyz=0 -0.57 0 rpy=0 0 0
